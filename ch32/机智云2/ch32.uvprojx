# Keil uVision project ch32.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CH32F103C8 WCH
  pack: Keil.WCH32F1xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ch32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\USER;.\hardware;.\system;.\Gizwits;.\Utils
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c
  group hardware
    ./hardware/: OLED.c OLED.h OLED_Font.h ds18b20.c ds18b20.h io_bit.h Key.c Key.h LED.c LED.h Serial.c Serial.h
  group system
    ./system/: Delay.c Delay.h Timer.c Timer.h
  group cloud
    ./Gizwits/: gizwits_product.c gizwits_protocol.c gizwits_protocol.h gizwits_product.h
    ./Utils/: common.c common.h dataPointTools.c dataPointTools.h ringbuffer.c ringBuffer.h
software components: CMSIS:CORE 5.0.1, CH32F1xx:Startup 1.0.0, CH32F1xx:StdPeriph Drivers:ADC 1.0.0, CH32F1xx:StdPeriph Drivers:CAN 1.0.0, CH32F1xx:StdPeriph Drivers:DMA 1.0.0, CH32F1xx:StdPeriph Drivers:EXTI 1.0.0, CH32F1xx:StdPeriph Drivers:Framework 1.0.0, CH32F1xx:StdPeriph Drivers:GPIO 1.0.0, CH32F1xx:StdPeriph Drivers:I2C 1.0.0, CH32F1xx:StdPeriph Drivers:RCC 1.0.0, CH32F1xx:StdPeriph Drivers:SPI 1.0.0, CH32F1xx:StdPeriph Drivers:TIM 1.0.0, CH32F1xx:StdPeriph Drivers:USART 1.0.0
