# Keil uVision project 51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h MatrixKey.c MatrixKey.h LCD1602.c LCD1602.h DS1302.c DS1302.h key.c key.h Timer.c Timer.h
